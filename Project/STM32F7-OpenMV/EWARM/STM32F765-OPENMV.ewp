# IAR project STM32F765-OPENMV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F765VI ST STM32F765VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F765xx
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Third Party\DECH\Camera; ..\..\..\Driver\STM32F7xx_HAL_Driver\Inc; ..\..\..\Driver\CMSIS\Include; ..\..\..\Driver\CMSIS\Device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F765-OPENMV.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../Driver/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f765xx.s
    ../src/: system_stm32f7xx.c
  group Driver/STM32F7xx_LL_Driver/inc
    ../../../Driver/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group Driver/STM32F7xx_LL_Driver/src
    ../../../Driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_dma.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c
  group User
    ../src/: main.c
  group User/ThirdParty/OV9650.
    ../../../Third Party/DECH/Camera/: camera.c ov9655.c sccb.c stm32f7xx_dcmi.c
